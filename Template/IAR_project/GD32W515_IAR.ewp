# IAR project GD32W515_IAR.ewp, settings and files
configuration GD32W515_EVAL (ARM)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SYS_NS; GD32W515; LV_CONF_INCLUDE_SIMPLE; LV_LVGL_H_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pa167,Pa089,Pe188,Pe236,Pe177,Pa118,Pe111,Pe191,Pe550,Pe186,Pe546,Pe549,Pa084
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32W51x_F5HC\Include; ..\..\Firmware\GD32W51x_F5HC_standard_peripheral\Include; ..; ..\GUI_APP\ui_lvgl; ..\GUI_APP\ui_lvgl\demos; ..\..\Utilities\bsp_drive; ..\..\Utilities\lvgl\lvgl; ..\..\Utilities\lvgl\lvgl\src; ..\..\Utilities\lvgl\lvgl_port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32W515_IAR.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: GD32W515xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32w51x_f5hc_it.c main.c systick.c
  group bsp_drive
    ../../Utilities/bsp_drive/: gd32w515p_eval.c lcd_driver.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32W51x_F5HC/Source/: system_gd32w51x_f5hc.c
  group Doc
    ../../: README.md
  group lvgl
    ../../Utilities/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Utilities/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Utilities/lvgl/lvgl/src/extra/: lv_extra.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../Utilities/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Utilities/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Utilities/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Utilities/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Utilities/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Utilities/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Utilities/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c
  group Peripherals
    ../../Firmware/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_adc.c gd32w51x_f5hc_cau.c gd32w51x_f5hc_cau_aes.c gd32w51x_f5hc_cau_des.c gd32w51x_f5hc_cau_tdes.c gd32w51x_f5hc_crc.c gd32w51x_f5hc_ctc.c gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dci.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_efuse.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_fwdgt.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_hau.c gd32w51x_f5hc_hau_sha_md5.c gd32w51x_f5hc_hpdf.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_icache.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pkcau.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_qspi.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_rtc.c gd32w51x_f5hc_sdio.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_sqpi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_trng.c gd32w51x_f5hc_tsi.c gd32w51x_f5hc_tzpcu.c gd32w51x_f5hc_usart.c gd32w51x_f5hc_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32W51x_F5HC/Source/IAR/: startup_gd32w515.s
  group ui_app
    ../GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c
    ../GUI_APP/ui_lvgl/: lv_widgets_slideshow.c lv_widgets_slideshow.h
  group ui_resource
    ../GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
