# Keil uVision project Project.uvprojx, settings and files
target GD32W515PIQ6 (6220000::V6.22::ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_F5HC_DFP.2.0.0
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,SYS_NS,GD32W515,GD32W515PI, LV_LVGL_H_INCLUDE_SIMPLE, LV_CONF_INCLUDE_SIMPLE, LV_DEMO_CONF_INCLUDE_SIMPLE,
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32W51x_F5HC\Include;..\..\Firmware\GD32W51x_F5HC_standard_peripheral\Include;..;..\GUI_APP\ui_lvgl\demos;..\..\Utilities\bsp_drive;..\..\Utilities\lvgl\lvgl;..\..\Utilities\lvgl\lvgl\src;..\..\Utilities\lvgl\lvgl_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  group Application
    ../: gd32w51x_f5hc_it.c main.c systick.c
  group Peripherals
    ../../Firmware/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_adc.c gd32w51x_f5hc_cau.c gd32w51x_f5hc_cau_aes.c gd32w51x_f5hc_cau_des.c gd32w51x_f5hc_cau_tdes.c gd32w51x_f5hc_crc.c gd32w51x_f5hc_ctc.c gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dci.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_efuse.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_fwdgt.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_hau.c gd32w51x_f5hc_hau_sha_md5.c gd32w51x_f5hc_hpdf.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_icache.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pkcau.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_qspi.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_rtc.c gd32w51x_f5hc_sdio.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_sqpi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_trng.c gd32w51x_f5hc_tsi.c gd32w51x_f5hc_tzpcu.c gd32w51x_f5hc_usart.c gd32w51x_f5hc_wwdgt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32W51x_F5HC/Source/: system_gd32w51x_f5hc.c
  group Doc
    ../../: README.md
  group Startup
    ../../Firmware/CMSIS/GD/GD32W51x_F5HC/Source/ARM/: startup_gd32w515.s
  group bsp_drive
    ../../Utilities/bsp_drive/: gd32w515p_eval.c lcd_driver.c
  group ui_app
    ../GUI_APP/ui_lvgl/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../GUI_APP/ui_lvgl/demos/: lv_demos.c
    ../GUI_APP/ui_lvgl/demos/benchmark/: lv_demo_benchmark.c
  group ui_resource
    ../GUI_APP/ui_lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../GUI_APP/ui_lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group lvgl
    ../../Utilities/lvgl/lvgl/src/: lv_init.c
    ../../Utilities/lvgl/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Utilities/lvgl/lvgl/src/fs/: lv_fs.c
    ../../Utilities/lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../Utilities/lvgl/lvgl/src/debugging/monkey/: lv_monkey.c
    ../../Utilities/lvgl/lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../../Utilities/lvgl/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../Utilities/lvgl/lvgl/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../Utilities/lvgl/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../../Utilities/lvgl/lvgl/src/display/: lv_display.c
    ../../Utilities/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Utilities/lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Utilities/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Utilities/lvgl/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../Utilities/lvgl/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../Utilities/lvgl/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../Utilities/lvgl/lvgl/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../Utilities/lvgl/lvgl/src/font/imgfont/: lv_imgfont.c
    ../../Utilities/lvgl/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../../Utilities/lvgl/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../../Utilities/lvgl/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../Utilities/lvgl/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Utilities/lvgl/lvgl/src/layouts/: lv_layout.c
    ../../Utilities/lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../../Utilities/lvgl/lvgl/src/layouts/grid/: lv_grid.c
    ../../Utilities/lvgl/lvgl/src/libs/barcode/: code128.c
    ../../Utilities/lvgl/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../../Utilities/lvgl/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../../Utilities/lvgl/lvgl/src/libs/gif/: gif.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_data/: lv_gltf_model_loader.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../../Utilities/lvgl/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../../Utilities/lvgl/lvgl/src/libs/lodepng/: lodepng.c
    ../../Utilities/lvgl/lvgl/src/libs/lz4/: lz4.c
    ../../Utilities/lvgl/lvgl/src/libs/nanovg/: nanovg.c
    ../../Utilities/lvgl/lvgl/src/libs/qrcode/: qrcodegen.c
    ../../Utilities/lvgl/lvgl/src/libs/rle/: lv_rle.c
    ../../Utilities/lvgl/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../Utilities/lvgl/lvgl/src/libs/tjpgd/: tjpgd.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_path.c vg_lite_stroke.c
    ../../Utilities/lvgl/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../../Utilities/lvgl/lvgl/src/logging/: lv_log.c
    ../../Utilities/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Utilities/lvgl/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Utilities/lvgl/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../../Utilities/lvgl/lvgl/src/stdlib/: lv_mem.c
    ../../Utilities/lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Utilities/lvgl/lvgl/src/themes/: lv_theme.c
    ../../Utilities/lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../../Utilities/lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Utilities/lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../Utilities/lvgl/lvgl/src/tick/: lv_tick.c
    ../../Utilities/lvgl/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Utilities/lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Utilities/lvgl/lvgl/src/widgets/arc/: lv_arc.c
    ../../Utilities/lvgl/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Utilities/lvgl/lvgl/src/widgets/bar/: lv_bar.c
    ../../Utilities/lvgl/lvgl/src/widgets/barcode/: lv_barcode.c
    ../../Utilities/lvgl/lvgl/src/widgets/button/: lv_button.c
    ../../Utilities/lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Utilities/lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Utilities/lvgl/lvgl/src/widgets/chart/: lv_chart.c
    ../../Utilities/lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Utilities/lvgl/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../../Utilities/lvgl/lvgl/src/widgets/gif/: lv_gif.c
    ../../Utilities/lvgl/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../../Utilities/lvgl/lvgl/src/widgets/image/: lv_image.c
    ../../Utilities/lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Utilities/lvgl/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../Utilities/lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Utilities/lvgl/lvgl/src/widgets/label/: lv_label.c
    ../../Utilities/lvgl/lvgl/src/widgets/led/: lv_led.c
    ../../Utilities/lvgl/lvgl/src/widgets/line/: lv_line.c
    ../../Utilities/lvgl/lvgl/src/widgets/list/: lv_list.c
    ../../Utilities/lvgl/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Utilities/lvgl/lvgl/src/widgets/menu/: lv_menu.c
    ../../Utilities/lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Utilities/lvgl/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../Utilities/lvgl/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../../Utilities/lvgl/lvgl/src/widgets/roller/: lv_roller.c
    ../../Utilities/lvgl/lvgl/src/widgets/scale/: lv_scale.c
    ../../Utilities/lvgl/lvgl/src/widgets/slider/: lv_slider.c
    ../../Utilities/lvgl/lvgl/src/widgets/span/: lv_span.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Utilities/lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Utilities/lvgl/lvgl/src/widgets/switch/: lv_switch.c
    ../../Utilities/lvgl/lvgl/src/widgets/table/: lv_table.c
    ../../Utilities/lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Utilities/lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Utilities/lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Utilities/lvgl/lvgl/src/widgets/win/: lv_win.c
  group lvgl_port
    ../../Utilities/lvgl/lvgl_port/: lv_port_disp.c
